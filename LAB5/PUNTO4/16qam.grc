options:
  parameters:
    author: Michel_S_Juan_R
    generate_options: qt_gui
    id: bpsk
    output_language: python
    title: QAM
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion )
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Carrier Freq. '
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb*2
  states: {}
- name: fd
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Deviation Freq
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (-3-3j, -1-3j,1-3j,3-3j,3-1j,1-1j,-1-1j,-3-1j,-3+1j,-1+1j,1+1j,3+1j,3+3j,1+3j,-1+3j,-3+3j)
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Message
    label1: RF Modulated. Time Domain
    label2: RF Modulated. Freq Domain
    label3: Constellation
    num_tabs: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.02'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport math\n\nclass blk(gr.sync_block):  \n    \"\"\"This block is a RF VCO and works as following: …..\"\"\"\n\n    def __init__(self, fc=128000, samp_rate=320000):  \n        gr.sync_block.__init__(\n            self,\n            name='e_RF_VCO_ff',   \n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n        self.fc = fc\n        self.samp_rate = samp_rate\n        self.n_m=0\n\n    def work(self, input_items, output_items):\n        A=input_items[0]\n        Q=input_items[1]\n        y=output_items[0]\n        N=len(A)\n        n=np.linspace(self.n_m,self.n_m+N-1,N)\n        self.n_m += N\n        y[:]=Q*np.cos(2*math.pi*self.fc*n/self.samp_rate+A)\n        return len(output_items[0])\n\n\n"
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  
          """This block is a CE VCO or baseband VCO and works as following: ….."""

          def __init__(self,):  
              gr.sync_block.__init__(
                  self,
                  name='e_CE_VCO_fc',   
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )
              
          def work(self, input_items, output_items):
              A=input_items[0]
              Q=input_items[1]
              y=output_items[0]
              N=len(A)
              y[:]=A*np.exp(1j*Q)
              return len(output_items[0])
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:3,1,1,1
    name: '"CE-Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:3,1,1,1
    label1: CE-Modulated Signal
    type: complex
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:2,1,1,1
    label1: RF Modulated Signal
    type: float
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:3,1,1,1
    label1: p2
    marker1: '0'
    name: '"Message bipolar"'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: complex
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:4,1,1,1
    label1: p1
    name: Modudating Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:2,1,1,1
    label1: Modulating Signal
    name: Modulating versus RF Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: CE Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p0
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4b
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p0
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: p2
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p3
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: p4b
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_const_source_x_0, '0', epy_block_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', epy_block_0_0, '0']
- [blocks_complex_to_magphase_0, '1', epy_block_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0_0_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '1']
- [interp_fir_filter_xxx_0, '0', blocks_complex_to_magphase_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
